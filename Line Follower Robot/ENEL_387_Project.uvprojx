# Keil uVision project ENEL_387_Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ENEL_387_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: ADC.c ADC.h gpio.c gpio.h interrupts.c interrupts.h LCD.c LCD.h motors.c motors.h sensors.c sensors.h main.c routines.c routines.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0
